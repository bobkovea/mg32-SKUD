# Keil uVision project OneWire.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: MG32F02A128 Megawin
  pack: Megawin.CM0_DFP.3.2.1
  cpu: IRAM(0x20000000,0x3800) IRAM2(0x20003800,0x800) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: LCDI +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3800
  memory RVCT10: RAM 0x20003800 size 0x800
  group src
    ./: main.c prsm3.c timers.c crc.c usart.c gpio.c wdt.c timers_irq.c usart_irq.c flash.c iap.c onewire.c ds18b20.c keys.c
  group inc
    ./: prsm3.h timers.h crc.h usart.h main.h gpio.h wdt.h flash.h iap.h onewire.h keys.h
software components: CMSIS:CORE 5.6.0, ChipInit_Wizard:CSC 1.0.4, ChipInit_Wizard:GPIO 1.0.0, ChipInit_Wizard:IRQ handler 1.0.5, ChipInit_Wizard:RST 1.0.1, ChipInit_Wizard:Timer 1.0.0, ChipInit_Wizard:URT 1.0.1, Device:Startup 1.0.4, Driver:Driver-All 1.0.1, IRQ_Handler:Enable TM0x NVIC:_TM01 1.0.0, IRQ_Handler:Enable TM10 NVIC 1.0.0, IRQ_Handler:Enable TM1x NVIC 1.0.0, IRQ_Handler:Enable URT0 NVIC 1.0.0
