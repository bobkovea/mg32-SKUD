# Keil uVision project TMC.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: MG32F02A032 Megawin
  pack: Megawin.CM0_DFP.3.6.0
  cpu: IRAM(0x20000000,0x1000) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: TMC +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group src
    ./: main.c isr.c skud_algo.c api.c bus.c timers.c gpio.c keys.c flash.c variables.c usart.c crc.c ibutton.c ring_buffer.c tests.c onewire.c md5.c iap.c wdt.c
  group inc
    ./: device_config.h isr.h skud_algo.h api.h bus.h timers.h crc.h usart.h gpio.h keys.h flash.h packages.h variables.h ibutton.h onewire.h md5.h ring_buffer.h wdt.h iap.h main.h
software components: CMSIS:CORE 5.6.0, ChipInit_Wizard:CSC 1.0.4, Device:Startup 1.0.4, Driver:Driver-All 1.0.2
